# Keil uVision project main.uvproj, settings and files
target Template (ARM-ADS)
  device: STM32F103RC STMicroelectronics
  cpu: IROM(0x08000000,0x40000) IRAM(0x20000000,0xC000) CPUTYPE("Cortex-M3") CLOCK(72000000) ELITTLE
  output: main +hex
  c flags: Optim=1
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\CORE;..\USER;..\LIB\PPP\inc;..\LIB\PPP\src;..\LIB\OTH\inc;..\LIB\OTH\src;..\LIB\PPPC\inc;..\LIB\PPPC\src
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group USER
    ./: stm32f10x_it.c system_stm32f10x.c main.cpp Retarget.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_hd.s
  group PPP
    ../LIB/PPP/src/: misc.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_exti.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_tim.c stm32f10x_usart.c
  group PPPC
    ../LIB/PPPC/src/: MISC_def.cpp NVIC_typedef.cpp RCC_typedef.cpp USART_typedef.cpp GPIO_typedef.cpp
